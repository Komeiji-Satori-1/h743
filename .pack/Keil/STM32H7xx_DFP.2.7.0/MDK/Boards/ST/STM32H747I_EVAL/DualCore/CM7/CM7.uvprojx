# Keil uVision project CM7.uvprojx, settings and files
target Debug (6140000::V6.14::ARMCLANG)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.1-dev8
  cpu: IRAM(0x24000000,0x00080000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: CM7
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\;..\Common;..\Common\STM32H7xx_HAL_Driver\Inc;..\Common\STM32H7xx_HAL_Driver\Inc\Legacy;..\Common\STM32H747I_EVAL_BSP
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  group BSP
    ../Common/STM32H747I_EVAL_BSP/: stm32h747i_eval.c
  group Source Files
    ./: main.c
  group Documentation
    ../: Abstract.txt
software components: CMSIS:CORE 5.3.0, Device:STM32Cube HAL:ADC 1.6.0, Device:STM32Cube HAL:Common 1.6.0, Device:STM32Cube HAL:Cortex 1.6.0, Device:STM32Cube HAL:DMA 1.6.0, Device:STM32Cube HAL:Flash 1.6.0, Device:STM32Cube HAL:GPIO 1.6.0, Device:STM32Cube HAL:HSEM 1.6.0, Device:STM32Cube HAL:I2C 1.6.0, Device:STM32Cube HAL:PWR 1.6.0, Device:STM32Cube HAL:RCC 1.6.0, Device:STM32Cube HAL:UART 1.6.0, Device:Startup 1.8.0

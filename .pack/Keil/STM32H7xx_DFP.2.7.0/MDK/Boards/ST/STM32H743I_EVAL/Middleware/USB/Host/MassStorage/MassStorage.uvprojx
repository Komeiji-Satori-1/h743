# Keil uVision project MassStorage.uvprojx, settings and files
target Debug (6140000::V6.14::ARMCLANG)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.1-dev8
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: MassStorage
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0x20000000 size 0x2000
  memory RVCT9: RAM 0x20002000 size 0x1e000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Source
    ./: MassStorage.c USBH_MSC.c USBH_MSC.h
  group Documentation
    ./: Abstract.txt
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32H743XIHx/STCubeGenerated/Src/: main.c stm32h7xx_it.c
    ./RTE/Device/STM32H743XIHx/STCubeGenerated/Inc/: stm32h7xx_it.h
target Release (6130001::V6.13.1::.\ARMCLANG)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.1-dev8
  cpu: as above
  output: MassStorage
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, CMSIS:RTOS2:Keil RTX5 5.5.2, Compiler:Event Recorder 1.4.0, Compiler:I/O:File 1.2.0, File System:CORE 6.13.8, File System:Drive:USB 6.13.8, USB:CORE 6.14.1, USB:CORE 6.14.1, USB:Host 6.14.1, USB:Host:MSC 6.14.1, Board Support:Drivers:BUS 1.1.0, Board Support:Drivers:Basic I/O 1.1.0, Board Support:Drivers:I/O 1.1.0, CMSIS Driver:USB Host 1.1.0, Device:STM32Cube HAL:ADC 1.8.0, Device:STM32Cube HAL:Common 1.8.0, Device:STM32Cube HAL:Cortex 1.8.0, Device:STM32Cube HAL:DMA 1.8.0, Device:STM32Cube HAL:EXTI 1.8.0, Device:STM32Cube HAL:GPIO 1.8.0, Device:STM32Cube HAL:HCD 1.8.0, Device:STM32Cube HAL:I2C 1.8.0, Device:STM32Cube HAL:MDMA 1.8.0, Device:STM32Cube HAL:PWR 1.8.0, Device:STM32Cube HAL:RCC 1.8.0, Device:STM32Cube HAL:SDRAM 1.8.0, Device:STM32Cube HAL:UART 1.8.0, Device:Startup 1.8.0

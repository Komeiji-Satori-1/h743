# Keil uVision project GUIDemo.uvprojx, settings and files
target Debug (6140000::V6.14::ARMCLANG)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.1-dev8
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: GUIDemo
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Source
    ./: GUIDemo.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32H743XIHx/STCubeGenerated/Src/: main.c stm32h7xx_it.c
    ./RTE/Device/STM32H743XIHx/STCubeGenerated/Inc/: stm32h7xx_it.h
  group Documentation
    ./: Abstract.txt
target Release (6140000::V6.14::ARMCLANG)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.1-dev8
  cpu: as above
  output: GUIDemo
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, CMSIS:RTOS2:Keil RTX5 5.5.2, Board Support:Drivers:BUS 1.1.0, Board Support:Drivers:Basic I/O 1.1.0, Board Support:Drivers:I/O 1.1.0, Board Support:Drivers:SDRAM 1.1.0, Board Support:Drivers:Touch Screen 1.1.0, Board Support:Joystick 1.1.0, Board Support:Touchscreen 1.1.0, Board Support:emWin LCD 1.1.0, Device:STM32Cube HAL:ADC 1.8.0, Device:STM32Cube HAL:Common 1.8.0, Device:STM32Cube HAL:Cortex 1.8.0, Device:STM32Cube HAL:DMA 1.8.0, Device:STM32Cube HAL:DMA2D 1.8.0, Device:STM32Cube HAL:EXTI 1.8.0, Device:STM32Cube HAL:GPIO 1.8.0, Device:STM32Cube HAL:I2C 1.8.0, Device:STM32Cube HAL:LTDC 1.8.0, Device:STM32Cube HAL:MDMA 1.8.0, Device:STM32Cube HAL:PWR 1.8.0, Device:STM32Cube HAL:RCC 1.8.0, Device:STM32Cube HAL:SDRAM 1.8.0, Device:STM32Cube HAL:TIM 1.8.0, Device:STM32Cube HAL:UART 1.8.0, Device:Startup 1.8.0, Graphics Display:STM32H743I-EVAL 1.0.2, Graphics:CORE 6.10.8, Graphics:Demo:AntialiasedText 6.10.8, Graphics:Demo:Automotive 6.10.8, Graphics:Demo:BarGraph 6.10.8, Graphics:Demo:Bitmap 6.10.8, Graphics:Demo:ColorBar 6.10.8, Graphics:Demo:Cursor 6.10.8, Graphics:Demo:Fading 6.10.8, Graphics:Demo:Framework 6.10.8, Graphics:Demo:Graph 6.10.8, Graphics:Demo:IconView 6.10.8, Graphics:Demo:ImageFlow 6.10.8, Graphics:Demo:ListView 6.10.8, Graphics:Demo:RadialMenu 6.10.8, Graphics:Demo:Skinning 6.10.8, Graphics:Demo:Speed 6.10.8, Graphics:Demo:TransparentDialog 6.10.8, Graphics:Demo:Treeview 6.10.8, Graphics:Demo:VScreen 6.10.8, Graphics:Demo:WashingMachine 6.10.8, Graphics:Input Device:Joystick 6.10.8, Graphics:Input Device:Touchscreen 6.10.8
